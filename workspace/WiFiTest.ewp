# IAR project WiFiTest.ewp, settings and files
configuration WiFiTest (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; EMW3162
  ICCARM.CCIncludePath2: ..\app; ..\include; ..\board\Whirlpool_Washer; ..\library; ..\network; ..\stm32f205\hld; ..\stm32f205\lld\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MXCHIP3162_JD_0101_001_V10.bin
  ILINK.IlinkOutputFile: JD-Smart.out
  ILINK.IlinkIcfFile: WiFiTest.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/: main.c network.c stm32f2xx_it.c tcp_udp_test.c wifi_test.c
  group library
    ../library/: cjson.c codec_bcd.c crc16.c RingBufferUtils.c
  group network
    ../network/: mico_config.c mxchipWNet_3162.a
  group stm32f205/hld
    ../stm32f205/hld/: comm_uart.c flash_if.c iwatchdog.c system_stm32f2xx.c
  group stm32f205/lld
    ../stm32f205/lld/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group stm32f205/startup
    ../stm32f205/startup/: startup_stm32f2xx.s
