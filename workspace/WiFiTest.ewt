<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>XiaoXiong</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>EMB380S</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Whirepool-Washer</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <file>
      <name>$PROJ_DIR$\..\app\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\network.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\stm32f2xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\tcp_udp_test.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\wifi_test.c</name>
    </file>
  </group>
  <group>
    <name>library</name>
    <file>
      <name>$PROJ_DIR$\..\library\cjson.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\codec_bcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\crc16.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\RingBufferUtils.c</name>
    </file>
  </group>
  <group>
    <name>network</name>
    <file>
      <name>$PROJ_DIR$\..\network\mico_config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\network\mxchipWNet_3162.a</name>
    </file>
  </group>
  <group>
    <name>stm32f205</name>
    <group>
      <name>hld</name>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\hld\comm_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\hld\flash_if.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\hld\iwatchdog.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\hld\system_stm32f2xx.c</name>
      </file>
    </group>
    <group>
      <name>lld</name>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_cryp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_cryp_aes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_cryp_des.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_cryp_tdes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_dcmi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_hash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_hash_md5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_hash_sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_rng.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\lld\src\stm32f2xx_wwdg.c</name>
      </file>
    </group>
    <group>
      <name>startup</name>
      <file>
        <name>$PROJ_DIR$\..\stm32f205\startup\startup_stm32f2xx.s</name>
      </file>
    </group>
  </group>
</project>


